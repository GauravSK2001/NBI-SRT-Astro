options:
  parameters:
    generate_options: hb
    id: filesink_post_int
    output_language: python
    title: filesink
  states: {}

blocks:
- name: File_save
  id: parameter
  parameters:
    label: 'File location '
    value: 2**13
  states: {}
- name: Vector_length
  id: parameter
  parameters:
    label: Vector Length
    value: 2**13
  states: {}
- name: blocks_file_sink_0_0_1_1
  id: blocks_file_sink
  parameters:
    file: File_save
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_head_1_1_1
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_1_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(Vector_length)/int_time
    type: float
    vlen: Vector_length
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: int_time
  id: parameter
  parameters:
    label: Integration Time
    value: '30'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
    vlen: Vector_length
  states: {}

connections:
- [blocks_head_1_1_1, '0', blocks_file_sink_0_0_1_1, '0']
- [blocks_multiply_const_vxx_1_1_1, '0', blocks_head_1_1_1, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_1_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
