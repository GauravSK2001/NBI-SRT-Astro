options:
  parameters:
    author: Gaurav
    generate_options: qt_gui
    id: Interferometry
    max_nouts: '1'
    output_language: python
    title: Interferometry
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1420.405751768e6
  states: {}
- name: int_time
  id: variable
  parameters:
    value: '30'
  states: {}
- name: one_sec_display_integration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: PPFB_hier_0
  id: PPFB_hier
  parameters:
    Vector_length: 2**13
  states: {}
- name: PPFB_hier_0_0
  id: PPFB_hier
  parameters:
    Vector_length: 2**13
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/flow
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_int
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_int
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_int
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_int
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/flow
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/flow
    type: float
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0_1_1
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/flow
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_0_0_1
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_1_0
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_1_0_0
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_head_1_0_1
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_1_1
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(vec_length)/int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(vec_length)/int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(vec_length)/int_time
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(vec_length)/int_time
    type: float
    vlen: vec_length
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'False'
    nthreads: '6'
    shift: 'True'
    type: complex
    window: window.hanning(vec_length)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'False'
    nthreads: '6'
    shift: 'True'
    type: complex
    window: window.hanning(vec_length)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Integration Time
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: airspy=0x14210000,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: osmosdr_source_1_0
  id: osmosdr_source
  parameters:
    args: airspy=0x14240000,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}

connections:
- [PPFB_hier_0, '0', fft_vxx_0_0_0, '0']
- [PPFB_hier_0_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_complex_to_magphase_0, '0', blocks_integrate_xx_0_0_0_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_integrate_xx_0_1_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_integrate_xx_0_0_0_1, '0']
- [blocks_complex_to_magphase_0, '1', blocks_integrate_xx_0_1_1, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_head_0_0_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_head_0_0_1, '0', blocks_file_sink_0_1_1, '0']
- [blocks_head_1, '0', blocks_file_sink_0_0, '0']
- [blocks_head_1_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_head_1_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_head_1_0_1, '0', blocks_file_sink_0_0_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_head_1, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_head_1_0, '0']
- [blocks_integrate_xx_0_0_0_0, '0', blocks_head_1_0_0, '0']
- [blocks_integrate_xx_0_0_0_1, '0', blocks_head_1_0_1, '0']
- [blocks_integrate_xx_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_integrate_xx_0_1_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_integrate_xx_0_1_1, '0', blocks_multiply_const_vxx_1_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_head_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_head_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_1, '0', blocks_head_0_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '0']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '1']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '2']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '3']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '4']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '5']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '6']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '7']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '8']
- [osmosdr_source_1, '0', PPFB_hier_0_0, '9']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '0']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '1']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '2']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '3']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '4']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '5']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '6']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '7']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '8']
- [osmosdr_source_1_0, '0', PPFB_hier_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
