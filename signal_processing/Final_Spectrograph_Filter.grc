options:
  parameters:
    author: gauravsenthilkumar
    generate_options: qt_gui
    id: Final_Spectrograph_Filter
    output_language: python
    run_options: run
    title: General Filter Bank
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: Frequency_Step_Size
  id: variable
  parameters:
    value: samp_rate/Vector_length
  states: {}
- name: HI21
  id: variable
  parameters:
    value: 1420.405751768e6
  states: {}
- name: Taps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: Vector_length
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: Window
  id: variable
  parameters:
    value: sinc
  states: {}
- name: int_time
  id: variable
  parameters:
    value: '30'
  states: {}
- name: one_sec_display_integration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*Taps/2.0, np.pi*Taps/2.0, np.pi/Vector_length)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: Taps
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 2*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 4*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 5*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    delay: 6*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    delay: 8*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2
  id: blocks_delay
  parameters:
    delay: 7*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2_0
  id: blocks_delay
  parameters:
    delay: 7*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2_0_0
  id: blocks_delay
  parameters:
    delay: 0*Vector_length
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/flow
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_int
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: int_time
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/Vector_length)
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/Vector_length)
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[:Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[Vector_length:2*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[2*Vector_length:3*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[3*Vector_length:4*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[4*Vector_length:5*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[5*Vector_length:6*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[6*Vector_length:7*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[8*Vector_length:9*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[7*Vector_length:8*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[9*Vector_length:10*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(Vector_length)/int_time
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Vector_length
    forward: 'True'
    nthreads: '6'
    shift: 'True'
    type: complex
    window: window.hanning(Vector_length)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Polyphase Functions
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Integration Time
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: HI21
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '''ztomag2'''
    name: '"Power Spectrum"'
    vlen: Vector_length
    x_axis_label: '"Frequency [MHz]"'
    x_start: (-samp_rate/2)/1e6
    x_step: (Frequency_Step_Size)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Power log"'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '''ztomag2'''
    name: '"Power Spectrum"'
    vlen: Vector_length
    x_axis_label: '"Frequency [MHz]"'
    x_start: (-samp_rate/2)/1e6
    x_step: (Frequency_Step_Size)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Power log"'
    ymin: '0'
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_stream_to_vector_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_1_0, '0', blocks_stream_to_vector_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_2, '0', blocks_stream_to_vector_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_0_2_0, '0', blocks_stream_to_vector_0_0_0_0_0_2_0, '0']
- [blocks_delay_0_0_0_0_2_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0_0, '0']
- [blocks_head_1, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_head_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_0_0_0_0_1, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0', blocks_add_xx_0, '8']
- [blocks_multiply_const_vxx_0_0_0_0_0_2, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_0_0_0_0_0_2_0, '0', blocks_add_xx_0, '9']
- [blocks_multiply_const_vxx_1, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_0_0_0_2, '0']
- [blocks_stream_to_vector_0_0_0_0_0_2_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_2_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_1, '0', blocks_delay_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_1, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_1_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_2, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_2_0, '0']
- [osmosdr_source_1, '0', blocks_delay_0_0_0_0_2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
