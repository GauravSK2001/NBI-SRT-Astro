options:
  parameters:
    author: Gaurav Senthil Kumar
    generate_options: hb_qt_gui
    id: PPFB_hier
    output_language: python
    title: 10 Tap Filter bank
  states: {}

blocks:
- name: Taps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: Window
  id: variable
  parameters:
    value: sinc
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*Taps/2.0, np.pi*Taps/2.0, np.pi/Vector_length)
  states: {}
- name: Vector_length
  id: parameter
  parameters:
    label: Length of FFT Vector
    value: 2**13
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: Taps
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 2*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 4*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 5*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    delay: 6*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    delay: 8*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2
  id: blocks_delay
  parameters:
    delay: 7*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2_0
  id: blocks_delay
  parameters:
    delay: 7*Vector_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2_0_0
  id: blocks_delay
  parameters:
    delay: 0*Vector_length
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[:Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[Vector_length:2*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[2*Vector_length:3*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[3*Vector_length:4*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[4*Vector_length:5*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[5*Vector_length:6*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[6*Vector_length:7*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[8*Vector_length:9*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[7*Vector_length:8*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Window[9*Vector_length:10*Vector_length]
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Polyphase Functions
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Output
    type: complex
    vlen: Vector_length
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    num_streams: '10'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_stream_to_vector_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_1_0, '0', blocks_stream_to_vector_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_2, '0', blocks_stream_to_vector_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_0_2_0, '0', blocks_stream_to_vector_0_0_0_0_0_2_0, '0']
- [blocks_delay_0_0_0_0_2_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_0_0_0_0_1, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0', blocks_add_xx_0, '8']
- [blocks_multiply_const_vxx_0_0_0_0_0_2, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_0_0_0_0_0_2_0, '0', blocks_add_xx_0, '9']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0']
- [blocks_stream_to_vector_0_0_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_0_0_0_2, '0']
- [blocks_stream_to_vector_0_0_0_0_0_2_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_2_0, '0']
- [pad_source_0, '0', blocks_delay_0_0_0_0_2_0_0, '0']
- [pad_source_0, '1', blocks_delay_0, '0']
- [pad_source_0, '2', blocks_delay_0_0, '0']
- [pad_source_0, '3', blocks_delay_0_0_0, '0']
- [pad_source_0, '4', blocks_delay_0_0_0_0, '0']
- [pad_source_0, '5', blocks_delay_0_0_0_0_0, '0']
- [pad_source_0, '6', blocks_delay_0_0_0_0_1, '0']
- [pad_source_0, '7', blocks_delay_0_0_0_0_2, '0']
- [pad_source_0, '8', blocks_delay_0_0_0_0_1_0, '0']
- [pad_source_0, '9', blocks_delay_0_0_0_0_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
