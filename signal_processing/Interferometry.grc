options:
  parameters:
    generate_options: qt_gui
    id: Interferometry
    output_language: python
    run_options: run
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: HI21
  id: variable
  parameters:
    value: 1420.405751768e6
  states: {}
- name: Vector_length
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: int_time
  id: variable
  parameters:
    value: '30'
  states: {}
- name: one_sec_display_integration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: prefix_hornA_1_sec
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/hornA/"'
  states: {}
- name: prefix_hornA_int_time
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/hornA/"'
  states: {}
- name: prefix_hornB_1_sec
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/hornB/"'
  states: {}
- name: prefix_hornB_int_time
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/hornB/"'
  states: {}
- name: prefix_mag_1_sec
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/magnitude/"'
  states: {}
- name: prefix_mag_int_time
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/magnitude/"'
  states: {}
- name: prefix_phase_1_sec
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/phase/"'
  states: {}
- name: prefix_phase_int_time
  id: variable
  parameters:
    value: '"/home/john/dspira_2021/interferometer_data/test_files/phase/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: PPFB_10tap_0
  id: PPFB_10tap
  parameters:
    Vector_length: Vector_length
  states: {}
- name: PPFB_10tap_0_0
  id: PPFB_10tap
  parameters:
    Vector_length: Vector_length
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_complex_to_real_1_1
  id: blocks_complex_to_real
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/Vector_length)
    type: complex
    vlen: Vector_length
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: Vector_length
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Vector_length
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.hanning(Vector_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: Vector_length
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.hanning(Vector_length)
  states: {}
- name: filesink_post_int_0
  id: filesink_post_int
  parameters:
    File_save: prefix_mag_1_sec
    Vector_length: Vector_length
    int_time: '1'
  states: {state: disabled}
- name: filesink_post_int_0_0
  id: filesink_post_int
  parameters:
    File_save: prefix_phase_1_sec
    Vector_length: Vector_length
    int_time: '1'
  states: {state: disabled}
- name: filesink_post_int_1
  id: filesink_post_int
  parameters:
    File_save: prefix_mag_int_time
    Vector_length: Vector_length
    int_time: '30'
  states: {state: disabled}
- name: filesink_post_int_1_0
  id: filesink_post_int
  parameters:
    File_save: prefix_phase_int_time
    Vector_length: Vector_length
    int_time: '30'
  states: {state: disabled}
- name: filesink_post_int_1_0_0
  id: filesink_post_int
  parameters:
    File_save: prefix_hornA_int_time
    Vector_length: Vector_length
    int_time: '1'
  states: {state: disabled}
- name: filesink_post_int_1_0_0_0
  id: filesink_post_int
  parameters:
    File_save: prefix_hornA_int_time
    Vector_length: Vector_length
    int_time: '30'
  states: {state: disabled}
- name: filesink_post_int_1_0_0_0_0
  id: filesink_post_int
  parameters:
    File_save: prefix_hornB_int_time
    Vector_length: Vector_length
    int_time: '30'
  states: {state: disabled}
- name: filesink_post_int_1_0_0_1
  id: filesink_post_int
  parameters:
    File_save: prefix_hornB_int_time
    Vector_length: Vector_length
    int_time: '1'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: DATA FILE PATHNAMES
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Integration Time
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: airspy=0x14214000,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: HI21
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: osmosdr_source_1_0
  id: osmosdr_source
  parameters:
    args: airspy=0x14212000,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: HI21
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    label1: '"Magnitude"'
    name: '"Correlation Magnitude"'
    vlen: Vector_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (HI21 - samp_rate/2)/1e6
    x_step: (samp_rate/Vector_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Magnitude"'
    ymax: '250'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    color1: '"red"'
    label1: '"Phase"'
    name: '"Correlation Phase"'
    vlen: Vector_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (HI21 - samp_rate/2)/1e6
    x_step: (samp_rate/Vector_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Phase"'
    ymax: '4'
    ymin: '-1'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    label1: '"Magnitude"'
    name: '"Horn A"'
    vlen: Vector_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (HI21 - samp_rate/2)/1e6
    x_step: (samp_rate/Vector_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
    ymax: '2000'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    label1: '"Magnitude"'
    name: '"Horn B"'
    vlen: Vector_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (HI21 - samp_rate/2)/1e6
    x_step: (samp_rate/Vector_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
    ymax: '2000'
    ymin: '0'
  states: {}

connections:
- [PPFB_10tap_0, '0', fft_vxx_0, '0']
- [PPFB_10tap_0_0, '0', fft_vxx_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', filesink_post_int_1_0_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', filesink_post_int_1_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0_0, '0', filesink_post_int_1_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_1, '0', filesink_post_int_1_0_0_1, '0']
- [blocks_complex_to_magphase_0, '0', filesink_post_int_1, '0']
- [blocks_complex_to_magphase_0, '1', filesink_post_int_1_0, '0']
- [blocks_complex_to_magphase_0_0, '0', filesink_post_int_0, '0']
- [blocks_complex_to_magphase_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_magphase_0_0, '1', filesink_post_int_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_complex_to_real_1_1, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_complex_to_real_1, '0']
- [blocks_integrate_xx_0_0_1, '0', blocks_complex_to_mag_squared_1_1, '0']
- [blocks_integrate_xx_0_0_1, '0', blocks_complex_to_real_1_1, '0']
- [blocks_integrate_xx_0_1, '0', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_integrate_xx_0_2, '0', blocks_complex_to_mag_squared_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_integrate_xx_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_integrate_xx_0_2, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [osmosdr_source_1, '0', PPFB_10tap_0, '0']
- [osmosdr_source_1_0, '0', PPFB_10tap_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
