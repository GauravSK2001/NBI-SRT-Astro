options:
  parameters:
    author: gauravsenthilkumar
    generate_options: qt_gui
    id: Final_Spectrograph_Filter_qttest
    output_language: python
    run_options: run
    title: General Filter Bank
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: HI21
  id: variable
  parameters:
    value: 1420.405751768e6
  states: {}
- name: Vector_length
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: int_time
  id: variable
  parameters:
    value: '300'
  states: {}
- name: one_sec_display_integration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: PPFB_0
  id: PPFB
  parameters:
    Vector_length: 2**13
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/long_int
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/gauravsenthilkumar/repositories/NBI-SRT-Astro/.cached_spectra/onesec_test
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(int_time*samp_rate/Vector_length)
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(one_sec_display_integration*samp_rate/Vector_length)
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.ones(Vector_length)/int_time
    type: float
    vlen: Vector_length
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Integration Time
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=0,pack=0
    bb_gain0: '12'
    clock_source0: external
    freq0: HI21
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: Vector_length
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [PPFB_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0, '0']
- [osmosdr_source_1, '0', PPFB_0, '0']
- [osmosdr_source_1, '0', PPFB_0, '1']
- [osmosdr_source_1, '0', PPFB_0, '2']
- [osmosdr_source_1, '0', PPFB_0, '3']
- [osmosdr_source_1, '0', PPFB_0, '4']
- [osmosdr_source_1, '0', PPFB_0, '5']
- [osmosdr_source_1, '0', PPFB_0, '6']
- [osmosdr_source_1, '0', PPFB_0, '7']
- [osmosdr_source_1, '0', PPFB_0, '8']
- [osmosdr_source_1, '0', PPFB_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
